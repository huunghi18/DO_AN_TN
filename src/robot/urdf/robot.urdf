Commit message: add

File: src/robot/urdf/robot.urdf (robot description, URDF)
Before this commit: robot my robot, 2 links, 1 joints
Links:
- link link1: geometry visual cylinder length=0.03 radius=0.06
Joints:
- joint joint1: axis 0 1 0 -> 0.0 1.0 0.0
